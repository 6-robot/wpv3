Commit message: new cali_vel

File: wpv3_bringup/urdf/wpv3.urdf (robot description, URDF)
Before this commit: robot WPV3, 6 links, 5 joints
Links:
- link laser: geometry visual cylinder length=0.01 radius=0.03
